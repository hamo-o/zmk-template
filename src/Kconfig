## src/Kconfig
```kconfig
config CUSTOM_ANIMATION_WIDGET
    bool "Custom animation widget for OLED"
    default y
    depends on ZMK_DISPLAY
```
